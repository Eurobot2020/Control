# Keil uVision project Actuadores_posavasos.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Actuadores_posavasos
  c flags: Optim=1
  c include: ..\USER;..\Libraries;..\Libraries\GLCD;..\Libraries\TouchPanel;..\Libraries\LPC1700CMSIS_Firmware_Library\include;..\Libraries\CM3\CoreSupport;..\Libraries\CM3\DeviceSupport
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ../Libraries/CM3/DeviceSupport/: system_LPC17xx.c startup_LPC17xx.s
  group user
    ../USER/: main.c state.c
    ../Libraries/: setup.c i2c_lpc17xx.c
  group Pantalla
    ../Libraries/GLCD/: GLCD.c AsciiLib.c
    ../Libraries/TouchPanel/: TouchPanel.c
    ../USER/: pantalla.c
  group CMSIS
    ../Libraries/LPC1700CMSIS_Firmware_Library/source/: lpc17xx_gpio.c lpc17xx_ssp.c lpc17xx_pinsel.c lpc17xx_clkpwr.c lpc17xx_libcfg_default.c
